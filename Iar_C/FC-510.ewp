# IAR project FC-510.ewp, settings and files
configuration LCD10 (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x80
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m8 ATmega8
  ICCAVR.CCDefines: LCD10
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm8.xcl
configuration LCD1601 (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: LCD16XX; LCD1601
configuration LCD1602 (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: LCD16XX; LCD1602
  group (top)
    ./: Count.c Disp.c Keyboard.c Lcd10.c Lcd16xx.c Main.c Menu.c Meter.c Port.c Sound.c
